# Keil uVision project infantry.uvprojx, settings and files
target infantry (6160000::V6.16::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;..\User\Chariot;..\User\Device;..\User\Internation;..\User\Middleware\alg;..\User\Middleware\drive;..\User\Task
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4lf_math.lib
  group Chariot
    ../User/Chariot/: crt_booster.cpp crt_gimbal.cpp
  group Device
    ../User/Device/: dvc_djimotor.cpp dvc_dr16.cpp dvc_minipc.cpp dvc_referee.cpp dvc_imu.cpp dvc_dwt.cpp dvc_boardc_bmi088.cpp dvc_boardc_ist8310.cpp flash.c
  group Internation
    ../User/Internation/: ita_chariot.cpp
  group Middleware/alg
    ../User/Middleware/alg/: alg_fsm.cpp alg_pid.cpp alg_MahonyAHRS.cpp kalman_filter.cpp PID.cpp QuaternionEKF.cpp user_lib.cpp
  group Middleware/drive
    ../User/Middleware/drive/: drv_can.cpp drv_math.cpp drv_tim.cpp drv_uart.cpp drv_usb.cpp drv_dwt.cpp drv_i2c.cpp drv_spi.cpp
  group Task
    ../User/Task/: task_callback_and_config.cpp
software components: CMSIS:CORE 5.6.0
