# Keil uVision project Stepper_motor_contral.uvprojx, settings and files
target Stepper_motor_contral (6160000::V6.16::ARMCLANG)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3") TZ
  output: Stepper_motor_contral +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F105xC
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User;../Middlewares;../User/Device;../User/Middleware/Algorithm;../User/Middleware/Driver;../User/Task
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Device
    ../User/Device/: dvc_djimotor.cpp
  group Middleware/Alogrithm
    ../User/Middleware/Algorithm/: alg_pid.cpp alg_power_limit.cpp
  group Middleware/Driver
    ../User/Middleware/Driver/: drv_can.cpp drv_dwt.cpp drv_math.cpp drv_tim.cpp
  group Middlewares
    ../Middlewares/: arm_math.h
  group Middlewares/Library/DSP
    ../Middlewares/: arm_cortexM3l_math.lib
  group Task
    ../User/Task/: task.cpp task.h
software components: CMSIS:CORE 5.5.0
